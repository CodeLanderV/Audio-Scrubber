options:
  parameters:
    author: satya
    generate_options: no_gui
    id: file_process
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: D:\Bunker\OneDrive - Amrita vishwa vidyapeetham\BaseCamp\AudioScrubber\Tests\captured.jpg.png
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: D:\Bunker\OneDrive - Amrita vishwa vidyapeetham\BaseCamp\AudioScrubber\Tests\denoised.jpg.png
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: D:\Bunker\OneDrive - Amrita vishwa vidyapeetham\BaseCamp\AudioScrubber\src\ofdm\gnu_ofdm\captured.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: D:\Bunker\OneDrive - Amrita vishwa vidyapeetham\BaseCamp\AudioScrubber\src\ofdm\gnu_ofdm\denoised.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    minoutbuf: '65536'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_1_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    minoutbuf: '65536'
    packed: 'True'
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"QPSK"'
    minoutbuf: '65536'
    occupied_carriers: ((-4, -3, -2, -1, 1, 2, 3, 4),)
    packet_len_key: '"packet_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-21, -7, 7, 21,),)
    pilot_symbols: ((1, 1, 1, -1),)
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_ofdm_rx_0_1
  id: digital_ofdm_rx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"QPSK"'
    minoutbuf: '65536'
    occupied_carriers: ((-4, -3, -2, -1, 1, 2, 3, 4),)
    packet_len_key: '"packet_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-21, -7, 7, 21,),)
    pilot_symbols: ((1, 1, 1, -1),)
    sync_word1: None
    sync_word2: None
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle2_1, '0']
- [blocks_throttle2_0, '0', digital_ofdm_rx_0, '0']
- [blocks_throttle2_1, '0', digital_ofdm_rx_0_1, '0']
- [digital_crc32_bb_1, '0', blocks_file_sink_0, '0']
- [digital_crc32_bb_1_0, '0', blocks_file_sink_1, '0']
- [digital_ofdm_rx_0, '0', digital_crc32_bb_1, '0']
- [digital_ofdm_rx_0_1, '0', digital_crc32_bb_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0

options:
  parameters:
    author: Dusan Stokic
    generate_options: qt_gui
    id: fm_receiver
    output_language: python
    title: FM Receiver
  states: {}

blocks:
- name: down_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: rfgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: RF Gain
    min_len: '20'
    rangeType: int
    start: '10'
    step: '5'
    stop: '70'
    value: '15'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: tuner
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: Station Select
    rangeType: int
    start: '87000000'
    step: '100000'
    stop: '108000000'
    value: '87000000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1
    label: Volume
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
    widget: slider
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: down_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '24000'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '24000'
  states: {}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    samp_rate: '24000'
  states: {}
- name: audio_sink_0_0_1
  id: audio_sink
  parameters:
    samp_rate: '24000'
  states: {}
- name: audio_sink_0_0_2
  id: audio_sink
  parameters:
    samp_rate: '24000'
  states: {}
- name: audio_sink_0_0_3
  id: audio_sink
  parameters:
    samp_rate: '24000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume/100
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block for FM Audio Denoising
      """

      import numpy as np
      from gnuradio import gr
      import torch
      import sys
      from pathlib import Path

      # --- CONFIGURATION (Update these paths!) ---
      # Path to your TRAINED FM MODEL
      MODEL_PATH = r"D:\Bunker\OneDrive - Amrita vishwa vidyapeetham\BaseCamp\AudioScrubber\saved_models\FM\FinalModels\FM_Final_1DUNET\general.pth"

      # Path to your SOURCE CODE (where neuralnet.py is)
      SRC_PATH = r"D:\Bunker\OneDrive - Amrita vishwa vidyapeetham\BaseCamp\AudioScrubber\src\fm\neuralnets"

      # Add src to system path
      if SRC_PATH not in sys.path:
          sys.path.append(SRC_PATH)

      # Import your model architecture
      try:
          from neuralnet import UNet1D  # Assuming class name is UNet1D for FM
      except ImportError:
          print("AI Block Error: Could not import UNet1D. Check sys.path.")

      class fm_ai_denoiser(gr.sync_block):  
          """
          FM AI Denoiser
          Takes float audio samples, runs them through 1D U-Net, outputs clean audio.
          """

          def __init__(self, chunk_size=16384): # 16000 is typical for speech models
              gr.sync_block.__init__(
                  self,
                  name='FM AI Denoiser',
                  in_sig=[np.float32],  # Audio is Float (Orange)
                  out_sig=[np.float32]  # Output is Float (Orange)
              )
              self.chunk_size = chunk_size
              self.device = torch.device("cuda" if torch.cuda.is_available() else "cpu")
              
              print(f"AI Block: Loading FM model from {MODEL_PATH}...")
              self.model = None
              self.load_model()

          def load_model(self):
              try:
                  # Initialize model (1 Channel for Audio)
                  self.model = UNet1D(in_channels=1, out_channels=1).to(self.device)
                  
                  # Load weights
                  checkpoint = torch.load(MODEL_PATH, map_location=self.device)
                  
                  if isinstance(checkpoint, dict) and 'model_state_dict' in checkpoint:
                      self.model.load_state_dict(checkpoint['model_state_dict'])
                  else:
                      self.model.load_state_dict(checkpoint)
                      
                  self.model.eval()
                  print("AI Block: FM Model loaded successfully.")
                  
              except Exception as e:
                  print(f"AI Block Error: {e}")
                  print("AI Block: Running in PASSTHROUGH mode.")
                  self.model = None

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]
              n_samples = len(in0)
              
              # Passthrough if model failed
              if self.model is None:
                  out0[:] = in0
                  return n_samples

              # Process in chunks
              num_chunks = n_samples // self.chunk_size
              valid_length = num_chunks * self.chunk_size
              
              if num_chunks > 0:
                  # 1. Reshape
                  data_chunks = in0[:valid_length].reshape(num_chunks, self.chunk_size)
                  
                  # 2. Tensor Prep (Batch, Channel, Length)
                  # Add channel dimension: (Num_Chunks, 1, Chunk_Size)
                  tensor_input = torch.from_numpy(data_chunks).float().unsqueeze(1).to(self.device)
                  
                  # 3. Inference
                  with torch.no_grad():
                      output_tensor = self.model(tensor_input)
                  
                  # 4. Output
                  # Remove channel dimension and flatten
                  clean_audio = output_tensor.squeeze(1).cpu().numpy().flatten()
                  out0[:valid_length] = clean_audio
                  
              # Pass remaining samples
              if valid_length < n_samples:
                  out0[valid_length:] = in0[valid_length:]

              return n_samples
    chunk_size: '16384'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block for FM Audio Denoising
      """

      import numpy as np
      from gnuradio import gr
      import torch
      import sys
      from pathlib import Path

      # --- CONFIGURATION (Update these paths!) ---
      # Path to your TRAINED FM MODEL
      MODEL_PATH = r"D:\Bunker\OneDrive - Amrita vishwa vidyapeetham\BaseCamp\AudioScrubber\saved_models\FM\FinalModels\FM_Final_STFT\speech.pth"

      # Path to your SOURCE CODE (where neuralnet.py is)
      SRC_PATH = r"D:\Bunker\OneDrive - Amrita vishwa vidyapeetham\BaseCamp\AudioScrubber\src\fm\neuralnets"

      # Add src to system path
      if SRC_PATH not in sys.path:
          sys.path.append(SRC_PATH)

      # Import your model architecture
      try:
          from neuralnet import UNet2D_STFT  # Assuming class name is UNet1D for FM
      except ImportError:
          print("AI Block Error: Could not import UNet1D. Check sys.path.")

      class fm_ai_denoiser(gr.sync_block):  
          """
          FM AI Denoiser
          Takes float audio samples, runs them through 1D U-Net, outputs clean audio.
          """

          def __init__(self, chunk_size=16384): # 16000 is typical for speech models
              gr.sync_block.__init__(
                  self,
                  name='FM AI Denoiser',
                  in_sig=[np.float32],  # Audio is Float (Orange)
                  out_sig=[np.float32]  # Output is Float (Orange)
              )
              self.chunk_size = chunk_size
              self.device = torch.device("cuda" if torch.cuda.is_available() else "cpu")
              
              print(f"AI Block: Loading FM model from {MODEL_PATH}...")
              self.model = None
              self.load_model()

          def load_model(self):
              try:
                  # Initialize model (1 Channel for Audio)
                  self.model = UNet1D(in_channels=1, out_channels=1).to(self.device)
                  
                  # Load weights
                  checkpoint = torch.load(MODEL_PATH, map_location=self.device)
                  
                  if isinstance(checkpoint, dict) and 'model_state_dict' in checkpoint:
                      self.model.load_state_dict(checkpoint['model_state_dict'])
                  else:
                      self.model.load_state_dict(checkpoint)
                      
                  self.model.eval()
                  print("AI Block: FM Model loaded successfully.")
                  
              except Exception as e:
                  print(f"AI Block Error: {e}")
                  print("AI Block: Running in PASSTHROUGH mode.")
                  self.model = None

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]
              n_samples = len(in0)
              
              # Passthrough if model failed
              if self.model is None:
                  out0[:] = in0
                  return n_samples

              # Process in chunks
              num_chunks = n_samples // self.chunk_size
              valid_length = num_chunks * self.chunk_size
              
              if num_chunks > 0:
                  # 1. Reshape
                  data_chunks = in0[:valid_length].reshape(num_chunks, self.chunk_size)
                  
                  # 2. Tensor Prep (Batch, Channel, Length)
                  # Add channel dimension: (Num_Chunks, 1, Chunk_Size)
                  tensor_input = torch.from_numpy(data_chunks).float().unsqueeze(1).to(self.device)
                  
                  # 3. Inference
                  with torch.no_grad():
                      output_tensor = self.model(tensor_input)
                  
                  # 4. Output
                  # Remove channel dimension and flatten
                  clean_audio = output_tensor.squeeze(1).cpu().numpy().flatten()
                  out0[:valid_length] = clean_audio
                  
              # Pass remaining samples
              if valid_length < n_samples:
                  out0[valid_length:] = in0[valid_length:]

              return n_samples
    chunk_size: '16384'
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block for FM Audio Denoising
      """

      import numpy as np
      from gnuradio import gr
      import torch
      import sys
      from pathlib import Path

      # --- CONFIGURATION (Update these paths!) ---
      # Path to your TRAINED FM MODEL
      MODEL_PATH = r"D:\Bunker\OneDrive - Amrita vishwa vidyapeetham\BaseCamp\AudioScrubber\saved_models\FM\FinalModels\FM_Final_STFT\general.pth"

      # Path to your SOURCE CODE (where neuralnet.py is)
      SRC_PATH = r"D:\Bunker\OneDrive - Amrita vishwa vidyapeetham\BaseCamp\AudioScrubber\src\fm\neuralnets"

      # Add src to system path
      if SRC_PATH not in sys.path:
          sys.path.append(SRC_PATH)

      # Import your model architecture
      try:
          from neuralnet import UNet2D_STFT  # Assuming class name is UNet1D for FM
      except ImportError:
          print("AI Block Error: Could not import UNet1D. Check sys.path.")

      class fm_ai_denoiser(gr.sync_block):  
          """
          FM AI Denoiser
          Takes float audio samples, runs them through 1D U-Net, outputs clean audio.
          """

          def __init__(self, chunk_size=16384): # 16000 is typical for speech models
              gr.sync_block.__init__(
                  self,
                  name='FM AI Denoiser',
                  in_sig=[np.float32],  # Audio is Float (Orange)
                  out_sig=[np.float32]  # Output is Float (Orange)
              )
              self.chunk_size = chunk_size
              self.device = torch.device("cuda" if torch.cuda.is_available() else "cpu")
              
              print(f"AI Block: Loading FM model from {MODEL_PATH}...")
              self.model = None
              self.load_model()

          def load_model(self):
              try:
                  # Initialize model (1 Channel for Audio)
                  self.model = UNet1D(in_channels=1, out_channels=1).to(self.device)
                  
                  # Load weights
                  checkpoint = torch.load(MODEL_PATH, map_location=self.device)
                  
                  if isinstance(checkpoint, dict) and 'model_state_dict' in checkpoint:
                      self.model.load_state_dict(checkpoint['model_state_dict'])
                  else:
                      self.model.load_state_dict(checkpoint)
                      
                  self.model.eval()
                  print("AI Block: FM Model loaded successfully.")
                  
              except Exception as e:
                  print(f"AI Block Error: {e}")
                  print("AI Block: Running in PASSTHROUGH mode.")
                  self.model = None

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]
              n_samples = len(in0)
              
              # Passthrough if model failed
              if self.model is None:
                  out0[:] = in0
                  return n_samples

              # Process in chunks
              num_chunks = n_samples // self.chunk_size
              valid_length = num_chunks * self.chunk_size
              
              if num_chunks > 0:
                  # 1. Reshape
                  data_chunks = in0[:valid_length].reshape(num_chunks, self.chunk_size)
                  
                  # 2. Tensor Prep (Batch, Channel, Length)
                  # Add channel dimension: (Num_Chunks, 1, Chunk_Size)
                  tensor_input = torch.from_numpy(data_chunks).float().unsqueeze(1).to(self.device)
                  
                  # 3. Inference
                  with torch.no_grad():
                      output_tensor = self.model(tensor_input)
                  
                  # 4. Output
                  # Remove channel dimension and flatten
                  clean_audio = output_tensor.squeeze(1).cpu().numpy().flatten()
                  out0[:valid_length] = clean_audio
                  
              # Pass remaining samples
              if valid_length < n_samples:
                  out0[valid_length:] = in0[valid_length:]

              return n_samples
    chunk_size: '16384'
  states: {}
- name: epy_block_0_2
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block for FM Audio Denoising
      """

      import numpy as np
      from gnuradio import gr
      import torch
      import sys
      from pathlib import Path

      # --- CONFIGURATION (Update these paths!) ---
      # Path to your TRAINED FM MODEL
      MODEL_PATH = r"D:\Bunker\OneDrive - Amrita vishwa vidyapeetham\BaseCamp\AudioScrubber\saved_models\FM\FinalModels\FM_Final_1DUNET\speech.pth"

      # Path to your SOURCE CODE (where neuralnet.py is)
      SRC_PATH = r"D:\Bunker\OneDrive - Amrita vishwa vidyapeetham\BaseCamp\AudioScrubber\src\fm\neuralnets"

      # Add src to system path
      if SRC_PATH not in sys.path:
          sys.path.append(SRC_PATH)

      # Import your model architecture
      try:
          from neuralnet import UNet1D  # Assuming class name is UNet1D for FM
      except ImportError:
          print("AI Block Error: Could not import UNet1D. Check sys.path.")

      class fm_ai_denoiser(gr.sync_block):  
          """
          FM AI Denoiser
          Takes float audio samples, runs them through 1D U-Net, outputs clean audio.
          """

          def __init__(self, chunk_size=16384): # 16000 is typical for speech models
              gr.sync_block.__init__(
                  self,
                  name='FM AI Denoiser',
                  in_sig=[np.float32],  # Audio is Float (Orange)
                  out_sig=[np.float32]  # Output is Float (Orange)
              )
              self.chunk_size = chunk_size
              self.device = torch.device("cuda" if torch.cuda.is_available() else "cpu")
              
              print(f"AI Block: Loading FM model from {MODEL_PATH}...")
              self.model = None
              self.load_model()

          def load_model(self):
              try:
                  # Initialize model (1 Channel for Audio)
                  self.model = UNet1D(in_channels=1, out_channels=1).to(self.device)
                  
                  # Load weights
                  checkpoint = torch.load(MODEL_PATH, map_location=self.device)
                  
                  if isinstance(checkpoint, dict) and 'model_state_dict' in checkpoint:
                      self.model.load_state_dict(checkpoint['model_state_dict'])
                  else:
                      self.model.load_state_dict(checkpoint)
                      
                  self.model.eval()
                  print("AI Block: FM Model loaded successfully.")
                  
              except Exception as e:
                  print(f"AI Block Error: {e}")
                  print("AI Block: Running in PASSTHROUGH mode.")
                  self.model = None

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]
              n_samples = len(in0)
              
              # Passthrough if model failed
              if self.model is None:
                  out0[:] = in0
                  return n_samples

              # Process in chunks
              num_chunks = n_samples // self.chunk_size
              valid_length = num_chunks * self.chunk_size
              
              if num_chunks > 0:
                  # 1. Reshape
                  data_chunks = in0[:valid_length].reshape(num_chunks, self.chunk_size)
                  
                  # 2. Tensor Prep (Batch, Channel, Length)
                  # Add channel dimension: (Num_Chunks, 1, Chunk_Size)
                  tensor_input = torch.from_numpy(data_chunks).float().unsqueeze(1).to(self.device)
                  
                  # 3. Inference
                  with torch.no_grad():
                      output_tensor = self.model(tensor_input)
                  
                  # 4. Output
                  # Remove channel dimension and flatten
                  clean_audio = output_tensor.squeeze(1).cpu().numpy().flatten()
                  out0[:valid_length] = clean_audio
                  
              # Pass remaining samples
              if valid_length < n_samples:
                  out0[valid_length:] = in0[valid_length:]

              return n_samples
    chunk_size: '16384'
  states: {}
- name: epy_block_0_3
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block for FM Audio Denoising
      """

      import numpy as np
      from gnuradio import gr
      import torch
      import sys
      from pathlib import Path

      # --- CONFIGURATION (Update these paths!) ---
      # Path to your TRAINED FM MODEL
      MODEL_PATH = r"D:\Bunker\OneDrive - Amrita vishwa vidyapeetham\BaseCamp\AudioScrubber\saved_models\FM\FinalModels\FM_Final_1DUNET\music.pth"

      # Path to your SOURCE CODE (where neuralnet.py is)
      SRC_PATH = r"D:\Bunker\OneDrive - Amrita vishwa vidyapeetham\BaseCamp\AudioScrubber\src\fm\neuralnets"

      # Add src to system path
      if SRC_PATH not in sys.path:
          sys.path.append(SRC_PATH)

      # Import your model architecture
      try:
          from neuralnet import UNet1D  # Assuming class name is UNet1D for FM
      except ImportError:
          print("AI Block Error: Could not import UNet1D. Check sys.path.")

      class fm_ai_denoiser(gr.sync_block):  
          """
          FM AI Denoiser
          Takes float audio samples, runs them through 1D U-Net, outputs clean audio.
          """

          def __init__(self, chunk_size=16384): # 16000 is typical for speech models
              gr.sync_block.__init__(
                  self,
                  name='FM AI Denoiser',
                  in_sig=[np.float32],  # Audio is Float (Orange)
                  out_sig=[np.float32]  # Output is Float (Orange)
              )
              self.chunk_size = chunk_size
              self.device = torch.device("cuda" if torch.cuda.is_available() else "cpu")
              
              print(f"AI Block: Loading FM model from {MODEL_PATH}...")
              self.model = None
              self.load_model()

          def load_model(self):
              try:
                  # Initialize model (1 Channel for Audio)
                  self.model = UNet1D(in_channels=1, out_channels=1).to(self.device)
                  
                  # Load weights
                  checkpoint = torch.load(MODEL_PATH, map_location=self.device)
                  
                  if isinstance(checkpoint, dict) and 'model_state_dict' in checkpoint:
                      self.model.load_state_dict(checkpoint['model_state_dict'])
                  else:
                      self.model.load_state_dict(checkpoint)
                      
                  self.model.eval()
                  print("AI Block: FM Model loaded successfully.")
                  
              except Exception as e:
                  print(f"AI Block Error: {e}")
                  print("AI Block: Running in PASSTHROUGH mode.")
                  self.model = None

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]
              n_samples = len(in0)
              
              # Passthrough if model failed
              if self.model is None:
                  out0[:] = in0
                  return n_samples

              # Process in chunks
              num_chunks = n_samples // self.chunk_size
              valid_length = num_chunks * self.chunk_size
              
              if num_chunks > 0:
                  # 1. Reshape
                  data_chunks = in0[:valid_length].reshape(num_chunks, self.chunk_size)
                  
                  # 2. Tensor Prep (Batch, Channel, Length)
                  # Add channel dimension: (Num_Chunks, 1, Chunk_Size)
                  tensor_input = torch.from_numpy(data_chunks).float().unsqueeze(1).to(self.device)
                  
                  # 3. Inference
                  with torch.no_grad():
                      output_tensor = self.model(tensor_input)
                  
                  # 4. Output
                  # Remove channel dimension and flatten
                  clean_audio = output_tensor.squeeze(1).cpu().numpy().flatten()
                  out0[:valid_length] = clean_audio
                  
              # Pass remaining samples
              if valid_length < n_samples:
                  out0[valid_length:] = in0[valid_length:]

              return n_samples
    chunk_size: '16384'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: int(samp_rate/down_rate)
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_3
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: tuner
    fftsize: '1024'
    grid: 'True'
    name: Sampling Bandpass
    nconnections: '2'
    type: float
    update_time: '0.1'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '250'
    interp: '24'
    taps: ''
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: str(grgsm.device.get_default_args(args))
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: tuner
    gain0: rfgain
    gain_mode0: 'True'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [epy_block_0, '0', audio_sink_0_0, '0']
- [epy_block_0, '0', qtgui_freq_sink_x_0_3, '0']
- [epy_block_0_0, '0', audio_sink_0_0_0, '0']
- [epy_block_0_1, '0', audio_sink_0_0_1, '0']
- [epy_block_0_2, '0', audio_sink_0_0_2, '0']
- [epy_block_0_3, '0', audio_sink_0_0_3, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', epy_block_0, '0']
- [rational_resampler_xxx_0, '0', epy_block_0_0, '0']
- [rational_resampler_xxx_0, '0', epy_block_0_1, '0']
- [rational_resampler_xxx_0, '0', epy_block_0_2, '0']
- [rational_resampler_xxx_0, '0', epy_block_0_3, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_3, '1']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
